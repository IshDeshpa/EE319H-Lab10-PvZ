# Keil uVision project Lab10_C++.uvprojx, settings and files
target Lab 10 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab10_C++
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\Keil
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup_TM4C123.s main.cpp DAC.cpp PLL.cpp random.cpp SlidePot.cpp Timer0.cpp UART.cpp FIFO.cpp diskio.c ff.c retarget.c TExaS.cpp ST7735SD.cpp Display.cpp uDMA.cpp uDMA.h TestFS.cpp TestFS.h
software components: CMSIS:CORE 5.0.2
